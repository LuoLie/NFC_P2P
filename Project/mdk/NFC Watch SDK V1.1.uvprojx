# Keil uVision project NFC Watch SDK V1.1.uvprojx, settings and files
target NFC Watch SDK V1.1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CanDo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD
  c misc: --c99 --cpp
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\src;..\src\battery;..\src\bsp;..\src\OLED;..\src\PN532\PN532_HSU;..\src\PN532
  memory RVCT4: ROM 0x8003000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../src/battery/: battery.h
    ../src/: main.cpp stm32f10x_it.c flash.c
    ../src/bsp/: bsp.c bsp.h tim.h tim.c
  group cmsis
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./: startup_stm32f10x_md.s
  group hal
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group oled
    ../src/OLED/: oled.h oled.c oled.lib
  group pn532
    ../src/PN532/PN532_HSU/: emdev.h PN532_HSU.h emdev.c PN532_HSU.cpp
    ../src/PN532/: llcp.h mac_link.h PN532.h PN532_debug.h PN532Interface.h snep.h llcp.cpp mac_link.cpp PN532.cpp snep.cpp
  group sample
    ../sample/: logo.cpp p2p.cpp rw Mifare tag.cpp surface.cpp InAutoPoll.cpp p2p_initiator.cpp
software components: CMSIS:CORE 4.1.0
